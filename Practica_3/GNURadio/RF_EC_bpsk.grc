options:
  parameters:
    author: radiogis_director
    generate_options: qt_gui
    id: ook
    output_language: python
    title: ook
  states: {}

blocks:
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Carrier Freq. '
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb*4
  states: {}
- name: fd
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Deviation Freq
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: Message
    label1: RF Modulated. Time Domain
    label2: RF Modulated. Freq Domain
    label3: Constellation
    num_tabs: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*math.pi*fd/(Rb*Sps)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: math.pi
    type: float
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np              # Importa la biblioteca NumPy para operaciones numéricas\nfrom gnuradio import gr         # Importa la clase base de GNU Radio para crear bloques\nimport math                     # Importa la biblioteca matemática para funciones como coseno\n\nclass blk(gr.sync_block):       # Define la clase 'blk' que hereda de 'gr.sync_block'\n    \"\"\"This block is a RF VCO and works as following: It acts as a continuous wave (CW) voltage-controlled oscillator (VCO) at baseband, generating a complex output signal based on an amplitude and a phase. This is commonly used in modulation and signal processing applications.\"\"\"\n\n    def __init__(self, fc=128000, samp_rate=320000):  \n        # Constructor que inicializa el bloque con frecuencia de portadora y tasa de muestreo\n        gr.sync_block.__init__(\n            self,\n            name='e_RF_VCO_ff',   # Nombre del bloque\n            in_sig=[np.float32, np.float32],  # Define las señales de entrada (amplitud y fase)\n            out_sig=[np.float32]  # Define la señal de salida\n        )\n        self.fc = fc              # Almacena la frecuencia de portadora\n        self.samp_rate = samp_rate  # Almacena la tasa de muestreo\n        self.n_m = 0              # Inicializa el contador de muestras procesadas\n\n    def work(self, input_items, output_items):\n        # Método que realiza el procesamiento de datos\n        A = input_items[0]        # Obtiene la señal de amplitud de la entrada\n        Q = input_items[1]        # Obtiene la señal de fase de la entrada\n        y = output_items[0]       # Prepara el buffer de salida\n        N = len(A)                # Obtiene el número de muestras en A\n        n = np.linspace(self.n_m, self.n_m + N - 1, N)  \n        # Crea un arreglo de índices de muestras desde n_m hasta n_m + N - 1\n        self.n_m += N             # Actualiza el contador de muestras procesadas\n        y[:] = A * np.cos(2 * math.pi * self.fc * n / self.samp_rate + Q)\n        # Calcula la señal de salida multiplicando A por el coseno con la frecuencia y fase\n        return len(output_items[0])  # Retorna el número de muestras procesadas\n\n\n\n"
    fc: fc
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np              # Importa la biblioteca NumPy para operaciones numéricas\nfrom gnuradio import gr         # Importa la clase base de GNU Radio para crear bloques\nimport math                     # Importa la biblioteca matemática (no se utiliza en este bloque)\n\nclass blk(gr.sync_block):       # Define la clase 'blk' que hereda de 'gr.sync_block'\n    \"\"\"This block is a CE VCO or baseband VCO and works as following: …..\"\"\"\n\n    def __init__(self,):  \n        # Constructor que inicializa el bloque sin parámetros adicionales\n        gr.sync_block.__init__(\n            self,\n            name='e_CE_VCO_fc',   # Nombre del bloque\n            in_sig=[np.float32, np.float32],  # Define las señales de entrada (amplitud y fase)\n            out_sig=[np.complex64]  # Define la señal de salida como compleja\n        )\n        \n    def work(self, input_items, output_items):\n        # Método que realiza el procesamiento de datos\n        A = input_items[0]        # Obtiene la señal de amplitud de la entrada\n        Q = input_items[1]        # Obtiene la señal de fase de la entrada\n        y = output_items[0]       # Prepara el buffer de salida\n        N = len(A)                # Obtiene el número de muestras en A\n        y[:] = A * np.exp(1j * Q) # Calcula la señal de salida como el producto de A y el exponencial complejo de Q\n        return len(output_items[0])  # Retorna el número de muestras procesadas\n\n"
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_Acum',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.acum=0
              
          def work(self, input_items, output_items):
              x=input_items[0]
              y= output_items[0]


              y[:]=self.acum+np.cumsum(x)
              self.acum=y[-1]
              return len(y)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@3:3,1,1,1
    name: '"CE-Constellation"'
    size: '1024'
    type: complex
    width1: '8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:2,1,1,1
    label1: RF Modulated Signal
    type: float
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:3,1,1,1
    label1: CE-Modulated Signal
    type: complex
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:3,1,1,1
    label1: p2
    marker1: '0'
    name: '"Message bipolar"'
    size: '16'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@0:4,1,1,1
    label1: p1
    name: Modudating Signal
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:2,1,1,1
    label1: Modulating Signal
    label2: RF Modulated signal
    name: Modulating versus RF Modulated Signal
    nconnections: '2'
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '4'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:3,1,1,1
    label1: I-Signal
    label2: Q-signal
    name: CE Modulated Signal
    size: 16*Sps
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p3
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4b
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: p3
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: p4
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: p4b
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '1']
- [analog_const_source_x_0, '0', epy_block_0_0, '1']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_0, '1']
- [blocks_multiply_const_vxx_0, '0', epy_block_0_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0_0, '0']
- [epy_block_0_0, '0', virtual_sink_0_0_0_0_0, '0']
- [epy_block_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [interp_fir_filter_xxx_0, '0', epy_block_0, '0']
- [interp_fir_filter_xxx_0, '0', epy_block_0_0, '0']
- [interp_fir_filter_xxx_0, '0', epy_block_0_1, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [virtual_source_0_1_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [virtual_source_0_1_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
